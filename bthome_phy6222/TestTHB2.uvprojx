# Keil uVision project TestTHB2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: TestTHB2 +hex
  AfterMake: fromelf.exe .\Objects\TestTHB2.axf --i32combined --output .\bin\TestTHB2.hex
  AfterMake: fromelf -c -a -d -e -v -o TestTHB2.asm ./Objects/TestTHB2.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_INFO=0  CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0  DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: .\SDK\components\inc;.\SDK\components\ble\controller;.\SDK\components\osal\include;.\SDK\components\common;.\SDK\components\ble\include;.\SDK\components\ble\hci;.\SDK\components\ble\host;.\SDK\components\Profiles\ota_app;.\SDK\components\Profiles\DevInfo;.\SDK\components\Profiles\SimpleProfile;.\SDK\components\Profiles\Roles;.\source;.\SDK\components\libraries\crc16;.\SDK\components\driver\watchdog;.\SDK\components\driver\clock;.\SDK\components\arch\cm0;.\SDK\components\driver\pwrmgr;.\SDK\components\driver\uart;.\SDK\components\driver\gpio;.\SDK\components\driver\timer;.\SDK\misc;.\SDK\components\driver\log;.\SDK\components\libraries\cliface;.\SDK\components\driver\key;.\SDK\components\driver\pwm;.\SDK\components\driver\flash;.\SDK\components\libraries\fs;.\SDK\components\driver\led_light;.\SDK\components\driver\i2c;.\SDK\components\Profiles\Batt;.\SDK\components\driver\adc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: .\SDK\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group driver
    ./SDK/components/driver/uart/: uart.c
    ./SDK/components/driver/clock/: clock.c
    ./SDK/components/driver/gpio/: gpio.c
    ./SDK/components/driver/watchdog/: watchdog.c
    ./SDK/components/driver/pwrmgr/: pwrmgr.c
    ./SDK/components/driver/log/: my_printf.c
    ./SDK/components/osal/snv/: osal_snv.c
    ./SDK/components/driver/flash/: flash.c
    ./SDK/components/libraries/fs/: fs.c
  group profile
    ./SDK/components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c
    ./SDK/components/profiles/GATT/: gattservapp.c
  group jump
    ./SDK/misc/: jump_table.c
  group lib
    ./SDK/lib/: rf.lib ble_host.lib
  group TestTHB2
    ./source/: peripheral_main.c thb2_main.c bthome_beacon.c sensors.c battery.c thservice.c main.c osal_peripheral.c thb2_peripheral.c devinfoservice.c battservice.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
